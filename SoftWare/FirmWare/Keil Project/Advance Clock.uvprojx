# Keil uVision project Advance Clock.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Advance Clock +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\Driver\inc;..\SourceCode\led;..\SourceCode\uart;..\SourceCode\timer;..\SourceCode\key;..\SourceCode\queue;..\SourceCode\msg_deal;..\SourceCode\ht_sensor;..\SourceCode\wdg;..\SourceCode\rtc;..\SourceCode;..\SourceCode\radio;..\SourceCode\common;..\SourceCode\nrf24l01;..\SourceCode\wifi;..\SourceCode\cJson;..\SourceCode\oled;..\SourceCode\bluetooth;..\SourceCode\show;..\SourceCode\region_header;..\SourceCode\cmd
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\build\AdvanceClock.sct
  group Driver
    ../Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Core
    ../Core/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group SourceCode
    ../SourceCode/: main.c
    ../SourceCode/LED/: led.c
    ../SourceCode/OLED/: oled.c
    ../SourceCode/UART/: uart.c
    ../SourceCode/KEY/: key.c
    ../SourceCode/Queue/: queue.c
    ../SourceCode/WDG/: iwdg.c
    ../SourceCode/RTC/: rtc.c
    ../SourceCode/COMMON/: common.c
    ../SourceCode/NRF24L01/: nrf24l01.c
    ../SourceCode/cJson/: cJSON.c
    ../SourceCode/bluetooth/: bluetooth.c
    ../SourceCode/wifi/: wifi.c
    ../SourceCode/timer/: timer.c
    ../SourceCode/oled/: bmp.c oledfont.c
    ../SourceCode/ht_sensor/: ht_sensor.c
    ../SourceCode/msg_deal/: msg_deal.c
    ../SourceCode/show/: show.c
    ../SourceCode/region_header/: region_header.c
    ../SourceCode/cmd/: cmd.c
