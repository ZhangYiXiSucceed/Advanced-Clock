# IAR project Advanced Clock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; __IAR_CC
  ICCARM.CCIncludePath2: Core; Driver; SourceCode; SourceCode\COMMON; SourceCode\HeadDef; SourceCode\HTSensor; SourceCode\KEY; SourceCode\LED; SourceCode\MsgDeal; SourceCode\NRF24L01; SourceCode\OLED; SourceCode\Queue; SourceCode\RADIO; SourceCode\RTC; SourceCode\TIM; SourceCode\UART; SourceCode\WDG; SourceCode\WIFI; SourceCode\BlueTooth; Driver\inc; SourceCode\cJson
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Advanced Clock.srec
  ILINK.IlinkOutputFile: Advanced Clock.out
  ILINK.IlinkIcfFile: Core\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Core
    Core/: startup_stm32f4xx.s stm32f4xx_it.c system_stm32f4xx.c
  group Driver
    Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SourceCode
    SourceCode/BlueTooth/: BlueTooth.c
    SourceCode/cJson/: cJSON.c
    SourceCode/COMMON/: common.c
    SourceCode/HTSensor/: HTSensor.c
    SourceCode/WDG/: iwdg.c
    SourceCode/KEY/: key.c
    SourceCode/LED/: led.c
    SourceCode/: main.c
    SourceCode/MsgDeal/: MsgDeal.c
    SourceCode/RADIO/: NB_IOT_BC26.c
    SourceCode/NRF24L01/: nrf24l01.c
    SourceCode/OLED/: oled.c
    SourceCode/Queue/: queue.c
    SourceCode/RTC/: rtc.c
    SourceCode/TIM/: timer.c
    SourceCode/UART/: uart.c
    SourceCode/WIFI/: WIFI.c
